# Keil uVision project Template.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 工程模板 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\user;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\APP\SysTick;.\APP\printf;.\APP\relay;.\APP\SPI;.\user\Function;.\user\LCDdriver;.\APP\Timer;.\APP\LED
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./user/: main.c stm32f10x_it.c public.c
    ./user/Function/: Fun.c
    ./user/LCDdriver/: LCDdv.c
  group cmsis
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group startup
    ./startup/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_spi.c
  group APP
    ./APP/SysTick/: systick.c
    ./APP/printf/: printf.c
    ./APP/relay/: relay.c
    ./APP/SPI/: SPI.c
    ./APP/Timer/: time.c
    ./APP/LED/: LED.c
